# Repository Forairaaaaa/E-LCD2

File README.md:

# E-LCD2

超级容易复刻，板载 2.0 寸 LCD 屏幕的 ESP32 核心板~

因为项目有 ESP32 + lcd 屏幕需求，所以干脆画个板载 LCD 的 ESP32 核心板，也刚好拿Kicad6练练手~

视频介绍：https://www.bilibili.com/video/BV13i4y197NZ

#### 核心板资源

- 安信可 ESP-32S 模组，焊接友好
- USB-C 接口，基于 CP2102（CH9102）USB-TTL 自动下载
- 复位按键、3 颗用户按键
- 2.0 寸 SPI LCD， 分辨率 240*320
- 引出绝大部分 IO

#### 缺点

- 没有板载 PSRAM ，所以单板不适合用于特别复杂的图形应用
- 用户按键所使用的 IO 为 ESP32 模组内部的 ADC2 复用引脚，在使用 WIFI 时要注意
- IO 口的排针引出没有标注丝印，作开发板玩时可能会有点麻烦 

#### 焊接注意

- 板子上 R5 默认不焊接，短接后 LCD 背光默认开启，不受引脚控制
- 板子上 R3 默认焊接，短接后 LCD 可以由引脚控制复位，避免出现上电后需要对板子手动复位， LCD 才能正常显示的问题
- 建议使用加热台，会方便很多~

#### 引脚定义

| 功能     | 引脚                                                 |
| -------- | ---------------------------------------------------- |
| LCD_MOSI | IO19                                                 |
| LCD_SCLK | IO18                                                 |
| LCD_CS   | IO5                                                  |
| LCD_DC   | IO16                                                 |
| LCD_RST  | IO17                                                 |
| LCD_BL   | IO4 （有复用风险？但目前没发现问题，下版本应该会换） |
| 用户按键 | 板子丝印有标注~                                      |

#### 例程

由于 LCD 涉及的配置文件比较多，例程中的库路径没有 ignore ~ 可以参考我的配置自行修改~~

#### 原理图

## KiCad design 1.Hardware/Kicad/E-LCD2/E-LCD2.kicad_pcb

File 1.Hardware/README.md:

# Hardware

PCB 为 Kicad 文件，封装可以直接导入Kicad使用

Gerber 路径下的压缩包可以直接发去打样~

BOM 路径下为可视化 BOM 表，焊接时对着看非常方便~

Parts:
C1, C4, C8: 10uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C5, C9: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 100uf; CAP-SMD_L3.5-W2.8-R-RD
C7: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
H1, H2: KH-2.54PH180-1X14P-L11.5; HDR-TH_14P-P2.54-V-M
J1: USB-C; USBC-16pin; PARTREV A3
LED1: Power; LED0603-R-RD
LED2: Test; LED0603-R-RD
Q1, Q2, Q3: S8050; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR
R1, R2, R6, R9, R12: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 0r; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: NC; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8: 12k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14, R15: 330r; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: Reset; SW-SMD_ST-1186S
SW2: Key-A; SW-SMD_ST-1186S
SW3: Key-B; SW-SMD_ST-1186S
SW4: Key-C; SW-SMD_ST-1186S
U1: AMS1117-3.3; SOT-223-3_L6.5-W3.4-P2.30-LS7.0-BR
U2: ESP32-S32MB; WIFIM-SMD_ESP32-S32MB
U3: CP2102-GM; QFN50P500X500X100-29N; PARTREV 1.8
U4: 2.0IPS_ST7789_12PIN; SPI-LCD2.0

Connections:
+3V3: C4.2, C5.2, C6.1, H2.13, R1.2, R2.2, R4.2, R9.1, U1.2 (VOUT), U1.4 (TAB), U2.2 (3V3), U4.4 (VCC_3.3V)
+5V: C1.2, C3.2, C8.2, C9.2, H1.12, H1.13, J1.A4_B9 (VBUS), J1.B4_A9 (VBUS), U1.3 (VIN), U3.7 (REGIN), U3.8 (VBUS)
/DN: J1.A7 (DN1), J1.B7 (DN2), U3.5 (D–)
/DP: J1.A6 (DP1), J1.B6 (DP2), U3.4 (D+)
/DTR: Q3.2 (E), R7.2, U3.28 (~DTR)
/EN: C2.2, Q2.3 (C), R1.1, SW1.1, U2.3 (EN)
/IO0: Q3.3 (C), U2.25 (IO0)
/IO2: H2.8, R14.2, U2.24 (IO2)
/IO12: H1.1, R12.2, U2.14 (IO12)
/IO13: R13.2, U2.16 (IO13)
/IO14: H1.2, U2.13 (IO14)
/IO15: H2.7, R15.2, U2.23 (IO15)
/IO21: H2.10, U2.33 (IO21)
/IO22: H2.11, U2.36 (IO22)
/IO23: H2.12, U2.37 (IO23)
/IO25: H1.5, U2.10 (IO25)
/IO26: H1.4, U2.11 (IO26)
/IO27: H1.3, U2.12 (IO27)
/IO32: H1.7, U2.8 (IO32)
/IO33: H1.6, U2.9 (IO33)
/IO34: H1.9, U2.6 (IO34)
/IO35: H1.8, U2.7 (IO35)
/K: Q1.3 (C), R5.2, U4.2 (K)
/LCD_BL: R6.1, R9.2, U2.26 (IO4)
/LCD_CS: U2.29 (IO5), U4.8 (CS)
/LCD_DC: U2.27 (IO16), U4.7 (SPI_A0)
/LCD_MOSI: U2.31 (IO19), U4.10 (SPI_SDA)
/LCD_RST/IO17: H2.9, R3.1, U2.28 (IO17)
/LCD_SCLK: U2.30 (IO18), U4.9 (SPI_SCL)
/RTS: Q2.2 (E), R8.2, U3.24 (~RTS)
/RX0: U2.34 (RXD0), U3.26 (TXD)
/SCK/CLK: H2.4, U2.20 (SCK/CLK)
/SCS/CMD: H2.3, U2.19 (SCS/CMD)
/SDI/SD1: H2.6, U2.22 (SDI/SD1)
/SDO/SD0: H2.5, U2.21 (SDO/SD0)
/SHD/SD2: H2.1, U2.17 (SHD/SD2)
/SWP/SD3: H2.2, U2.18 (SWP/SD3)
/S_VN: H1.10, U2.5 (SENSOR_VN)
/S_VP: H1.11, U2.4 (SENSOR_VP)
/TX0: U2.35 (TXD0), U3.25 (RXD)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.2, C7.2, C8.1, C9.1, H1.14, H2.14, J1.A1_B12 (GND), J1.B1_A12 (GND), J1.S1 (SHELL_GND), J1.S2 (SHELL_GND), J1.S3 (SHELL_GND), J1.S4 (SHELL_GND), LED1.2 (C), LED2.2 (C), Q1.2 (E), R5.1, R10.2, R11.2, SW1.2, SW2.2, SW3.2, SW4.2, U1.1 (GND), U2.1 (GND), U2.15 (GND), U2.38 (GND), U2.39 (EP), U3.3 (GND), U3.29 (GND), U4.1 (GND), U4.5 (GND), U4.6 (GND), U4.12 (GND)
unnamed: C7.1, U3.6 (VDD)
unnamed: J1.A5 (CC1), R10.1
unnamed: J1.B5 (CC2), R11.1
unnamed: LED1.1 (A), R2.1
unnamed: LED2.1 (A), R12.1
unnamed: Q1.1 (B), R6.2
unnamed: Q2.1 (B), R7.1
unnamed: Q3.1 (B), R8.1
unnamed: R3.2, U4.11 (/RESET)
unnamed: R4.1, U4.3 (A)
unnamed: R13.1, SW2.1
unnamed: R14.1, SW3.1
unnamed: R15.1, SW4.1

Notes on the sheet:
引脚引出：2 x 1x14P 2.54mm 排针
DC-DC
项目仓库：https://gitee.com/forairaaaaa/e-lcd2.git
USB_TTL 自动下载，CP2102可用CH9102代替
R5：短接（0Ω），失能IO4作LCD背光控制引脚
R3：短接（0Ω），使能IO17作LCD复位引脚
PIN-MAP: LED: IO12 Key-A: IO13 Key-B: IO2 Key-C: IO15
R4：串联LCD背光，改变阻值以调节LCD背光亮度
2.0寸 12pin SPI LCD
LCD-PIN-MAP: MOSI: IO19 SCLK: IO18 CS: IO5 DC: IO16 RST: IO17 BL: IO4
USB-C
作者：https://space.bilibili.com/35053144
用户LED、按键
安信可ESP-32S模组

Board: 2 copper layers, 58.3 x 36.3 mm, 40 parts (39 on the bottom side), 54 nets.

## Commit log

2021-12-28 删除文件 README.en.md
2021-12-28 add LICENSE.
2021-12-28 add kicad project
2021-12-28 PCB done
2021-12-28 add gerber and sch.pdf
2022-01-04 add ibom.html and footprint..
2022-01-04 remove some thing
2022-01-04 add lcd doc
2022-01-08 update main
2022-04-12 update README.md.
